# Keil uVision project AstroParty.uvproj, settings and files
target AstroParty (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: AstroParty
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ../src/: ADC.c AstroParty.c DAC.c GamePhysics.c InputHardware.c LCDBuffer.c PLL.c RandomGenerate.c Sound.c ST7735.c Timer0.c LCD.s Print.s random.s startup.s
  group Header Files
    ../src/: ADC.h AstroParty.h DAC.h GameObjects.h GamePhysics.h Images.h InputHardware.h LCD.h LCDBuffer.h PLL.h print.h random.h RandomGenerate.h Sound.h Sounds.h ST7735.h TExaS.h Timer0.h tm4c123gh6pm.h
